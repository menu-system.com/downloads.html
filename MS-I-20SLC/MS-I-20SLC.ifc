Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T13:33:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 13:33:32 2023 * Host: CAD-PC-05 * Database: C:\Temp\{622471F2-0975-4DBA-8E56-B860A7C858A3}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 13:33:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 13:33:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 13:33:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: 2er à la carte-SLIDECONTROL-Kochfeld_MS-I-20 ES, 2er à la carte-Kochfeld mit SLIDECONTROL_MS-I-20 ES:2er à la carte-SLIDECONTROL-Kochfeld_MS-I-20 ES:361826
In: Ebene 0
Type - Material: MS_Finishes_Red, MS_Finishes_Black_shiny, MS_Finishes_Alu, MS_Finishes_Stainless_Steel, MS_Finishes_White, MS_Finishes_Red dark, MS_Ceramic_Glass
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: Einbau Induktionsgerät mit 2 à la carte-Kochfeldern mit SLIDECONTROL Technologie; Typenkommentare: MS-I-20 ES; Länge Gerätebreite: 388 mm; Tiefe: 226 mm; Höhe: 76.2 mm; Artikel Nummer: 310308; Gerätegewicht Netto: 28; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-kochfelder.html#4348; Spannung: 400 V; Elektrische leistung: 7000 W; Stecker System: CEE16; Maximale Geräteabsicherung: 16 A; Phasen: 2; Frequenz: 50 Hz
