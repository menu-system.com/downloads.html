Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T13:46:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 13:46:44 2023 * Host: CAD-PC-05 * Database: C:\Temp\{11947D67-8805-4BA1-9E72-1A8C3F4ED6EB}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 13:46:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 13:46:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 13:46:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: Power-Kochfeld_MS-I-10 EP, MS-I-10 EP_Power-Kochfeld:Power-Kochfeld_MS-I-10 EP:361826
In: Ebene 0
Type - Material: MS_Finishes_Red, MS_Finishes_Black_shiny, MS_Finishes_Alu, MS_Finishes_Red dark, MS_Ceramic_Glass, MS_Finishes_Stainless_Steel
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: Einbau Induktionsgerät mit Power Rundspule, einseitig bedienbar; Typenkommentare: MS-I-10 EP; Länge Gerätebreite: 388 mm; Tiefe: 388 mm; Höhe: 126 mm; Artikel Nummer: 310284; Gerätegewicht Netto: 16; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-kochfelder.html#4345; Spannung: 400 V; Elektrische leistung: 6000 W; Stecker System: Typ 15 oder CEE 16; Maximale Geräteabsicherung: 10 A; Phasen: 3; Frequenz: 50 Hz
