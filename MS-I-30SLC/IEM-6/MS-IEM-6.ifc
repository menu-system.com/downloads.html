Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T14:00:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 14:00:38 2023 * Host: CAD-PC-05 * Database: C:\Temp\{574C6CCC-6FA8-457C-8C4A-6FB0D0E387A5}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 14:00:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 14:00:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 14:00:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: Einbaumodul IEM-6, MS-IEM-6-Einbaumodul:Einbaumodul IEM-6:361826
In: Ebene 0
Type - Material: MS_Finishes_Stainless_Steel
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: MS-IEM-6; Länge Gerätebreite: 350 mm; Tiefe: 365 mm; Höhe: 100 mm; Artikel Nummer: 310231; Gerätegewicht Netto: 7; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-warmhalteplatte.html#4360; Spannung: 400 V; Elektrische leistung: 0 W; Maximale Geräteabsicherung: 0 A; Phasen: 0; Frequenz: 50 Hz
