Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T14:01:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 14:01:29 2023 * Host: CAD-PC-05 * Database: C:\Temp\{DDC183E9-BCE7-4D05-A899-2A70865FB443}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 14:01:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 14:01:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 14:01:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: MS-IFU-250, MS-IFU-250:MS-IFU-250:361826
In: Ebene 0
Type - Material: MS_Finishes_Stainless_Steel
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: MS-IFU-250; Typenkommentare: für 1-2 Celsius Black Induktionsgeneratoren; Länge Gerätebreite: 250 mm; Tiefe: 445 mm; Höhe: 560 mm; Artikel Nummer: 207035; Gerätegewicht Netto: 0; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-kochfelder.html#4348; Spannung: 0 V; Elektrische leistung: 0 W; Maximale Geräteabsicherung: 0 A; Phasen: 0; Frequenz: 0 Hz
