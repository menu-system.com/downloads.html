Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T13:54:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 13:54:01 2023 * Host: CAD-PC-05 * Database: C:\Temp\{3D21B3A9-CD74-4CD9-BD33-74297114D5A1}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 13:54:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 13:54:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 13:54:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: 2er Multifunktions-Kochfeld_MS-I-20 EM SEB, schmalseitig einseitig bedienbar, MS-I-20 EM-SEB_2er Multifunktions-Kochfeld:2er Multifunktions-Kochfeld_MS-I-20 EM SEB, schmalseitig einseitig bedienbar:361826
In: Ebene 0
Type - Material: MS_Finishes_Red, MS_Finishes_Black_shiny, MS_Finishes_Alu, MS_Ceramic_Glass, MS_Finishes_Stainless_Steel, MS_Finishes_Red dark
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: Einbau Induktionsgerät mit 2 Multifunktions-Spulen, schmalseitig einseitig bedienbar; Typenkommentare: MS-I-20 EM SEB; Länge Gerätebreite: 356 mm; Tiefe: 656 mm; Höhe: 126 mm; Artikel Nummer: 310301; Gerätegewicht Netto: 32; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einbaugeraete-kochfelder.html#4349; Spannung: 400 V; Elektrische leistung: 14000 W; Stecker System: CEE 16; Maximale Geräteabsicherung: 16 A; Phasen: 3; Frequenz: 50 Hz
