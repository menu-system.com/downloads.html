Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2023-11-20T13:37:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 13:37:59 2023 * Host: CAD-PC-05 * Database: C:\Temp\{1C073C8D-A0F1-4305-AEF3-15344B1B7B64}\ifc * Database version: 5507 * Database creation date: Mon Nov 20 13:37:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 13:37:58 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 13:37:58 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcFurnishingElement: Einbau-Bräter_MS-B-60 E, MS-B-60 E_Einbau-Braeter:Einbau-Bräter_MS-B-60 E:361826
In: Ebene 0
Type - Material: MS_Finishes_Stainless_Steel, MS_Finishes_White
Pset_ManufacturerTypeInformation - Manufacturer: Menu System AG; Hersteller: Menu System AG; Modell: Einbau Bräter 60*60 mit 2 Heizzonen; Typenkommentare: MS-B-60 E; Länge Gerätebreite: 608 mm; Tiefe: 608 mm; Höhe: 230.9 mm; Artikel Nummer: 120739; Gerätegewicht Netto: 66; Großküchengerätezuordnung: yes; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/einzelgeraete-grillplatten-braeter.html#4363; Spannung: 400 V; Elektrische leistung: 7200 W; Stecker System: CEE 16; Maximale Geräteabsicherung: 16 A; Phasen: 3; Frequenz: 50 Hz
